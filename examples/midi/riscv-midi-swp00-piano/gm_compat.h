#ifndef MU50_GM_COMPAT_H
#define MU50_GM_COMPAT_H

// Closest MU50 presets for common GS and GM2 variations
// Zero GS/GM2 bank entries mean that dialect has no matching variation
static const struct { u8 program, gs, gm2, xg; } variations[] = {
    {0,8,1,1}, {0,16,2,18}, {1,8,1,1}, {2,8,1,32}, {3,8,1,1},
    {4,8,1,32}, {4,16,2,45}, {4,24,3,64},
    {5,8,1,32}, {5,16,2,45}, {5,24,3,34}, {5,0,4,40},
    {6,8,1,25}, {6,16,2,35}, {6,24,3,1}, {7,8,1,1},
    {11,8,1,0}, {12,8,1,0}, {14,8,1,0}, {14,9,2,0},
    {16,8,1,32}, {16,16,2,33}, {16,0,3,35},
    {17,8,1,32}, {17,0,2,24}, {19,8,1,35}, {19,16,2,40},
    {21,8,1,0}, {24,8,1,96}, {24,16,2,16}, {24,0,3,25},
    {25,8,1,35}, {25,16,2,96}, {25,0,3,40},
    {26,8,1,0}, {27,8,1,32}, {27,0,2,0},
    {28,8,1,40}, {28,16,2,43}, {28,0,3,45},
    {30,8,1,40}, {31,8,1,65}, {33,8,1,0},
    {38,1,1,64}, {38,2,2,24}, {38,3,3,35}, {38,8,4,96},
    {39,1,1,6}, {39,2,2,12}, {39,8,3,32}, {39,16,4,41},
    {40,8,1,0}, {48,8,1,40}, {48,16,2,35},
    {50,8,1,64}, {52,8,1,32}, {52,16,2,16}, {53,8,1,0},
    {55,8,1,35}, {55,9,2,64}, {55,10,3,64},
    {56,8,1,32}, {57,1,1,18}, {59,8,1,0},
    {60,1,1,6}, {61,8,1,40}, {62,8,1,27}, {62,16,2,64},
    {63,8,1,40}, {63,16,2,64},
    {80,1,1,6}, {80,8,2,65}, {81,1,1,6}, {81,8,2,40},
    {81,0,3,8}, {81,0,4,24}, {81,0,5,96},
    {98,1,1,64}, {102,1,1,64}, {102,2,2,14},
    {104,1,1,35}, {107,8,1,96}, {115,8,1,96},
    {116,8,1,96}, {117,8,1,65}, {117,0,2,66},
    {118,8,1,64}, {118,9,2,65}
};

static u8 compatible_bank(const GmChannel *c) {
    u32 i;
    u8 bank = c->bank_msb == 121 ? c->bank_lsb : c->bank_msb;
    if (!bank) return 0;
    for (i = 0; i < sizeof variations / sizeof variations[0]; ++i)
        if (variations[i].program == c->program &&
            bank == (c->bank_msb == 121 ? variations[i].gm2 : variations[i].gs))
            return variations[i].xg;
    return 0;
}

// GS extensions below note 35 have different assignments from XG
static u8 compatible_drum_note(u8 note) {
    static const u8 low[] = {255,255,38,29,19,15,16,17,18,32,20,21,22};
    if (note < 22) return 255;
    if (note < 35) return low[note - 22];
    return note <= 87 ? note : 255;
}

#endif
